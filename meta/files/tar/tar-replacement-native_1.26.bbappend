do_configure_prepend() {
	export AUTOPOINT=true
}
