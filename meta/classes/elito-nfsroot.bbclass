# for IMAGE_ROOTFS
OVERRIDES .= ":elito-nfsroot"
