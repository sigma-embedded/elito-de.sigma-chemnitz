do_build[depends] += "elito-makefile:do_prepare_all_sysroots"
