AR = "${HOST_PREFIX}gcc-ar"
NM = "${HOST_PREFIX}gcc-nm"
RANLIB = "${HOST_PREFIX}gcc-ranlib"

BUILD_AR="${BUILD_PREFIX}gcc-ar"
BUILD_NM="${BUILD_PREFIX}gcc-nm"
BUILD_RANLIB="${BUILD_PREFIX}gcc-ranlib"
