require dietlibc-git.inc
require dietlibc-sdk.inc
