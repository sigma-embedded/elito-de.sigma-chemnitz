require dietlibc-cvs.inc
require dietlibc-sdk.inc
