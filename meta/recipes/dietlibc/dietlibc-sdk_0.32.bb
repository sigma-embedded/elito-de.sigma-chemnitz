require dietlibc-${PV}.inc
require dietlibc-sdk.inc
