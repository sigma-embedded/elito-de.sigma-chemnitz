DESCRIPTION = "Pseudo receipt to build + rm_work the core toolchain"
DEPENDS = "virtual/${TARGET_PREFIX}gcc virtual/libc"
PACKAGES = ""
PACKAGE_ARCH = "all"
INHIBIT_DEFAULT_DEPS = "1"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://${COREBASE}/meta/COPYING.MIT;md5=3da9cfbcb788c80a0384361b4de20420"

do_compile() {
    :
}

do_configure() {
    :
}

do_install() {
    :
}

do_package() {
    :
}
