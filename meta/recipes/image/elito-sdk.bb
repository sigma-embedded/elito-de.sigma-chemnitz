IMAGE_FEATURES += "\
  tools-sdk dev-pkgs tools-debug tools-profile \
  tools-testapps debug-tweaks"

require elito-image.inc

