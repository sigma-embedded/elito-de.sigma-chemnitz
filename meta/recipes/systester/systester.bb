SUMMARY = "Tests system stability by calculating PI"
LICENSE = "GPLv2"
SRC_URI = "${SOURCEFORGE_MIRROR}/${PN}/1.5.0/${PN}-${PV}.tar.gz"

inherit autotools
