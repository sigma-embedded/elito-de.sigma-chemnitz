DESCRIPTION = "Pseudo receipt to build + rm_work the core toolchain"
DEPENDS = "virtual/${TARGET_PREFIX}gcc virtual/libc"
PACKAGES = ""
PACKAGE_ARCH = "all"
INHIBIT_DEFAULT_DEPS = "1"

do_compile() {
    :
}

do_configure() {
    :
}

do_install() {
    :
}

do_package() {
    :
}
