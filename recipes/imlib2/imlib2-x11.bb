include imlib2.inc

DEPENDS += "libx11 libxext"
EXTRA_OECONF += "--with-x"
