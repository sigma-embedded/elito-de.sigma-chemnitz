require arnoldboot-native.bb

COMPONENT  = "arnoldboot"
PV         = "0.0"

inherit elito-develcomp
