inherit native
require libnih.inc

RREPLACES += "upstart-native (< 0.6.5)"
