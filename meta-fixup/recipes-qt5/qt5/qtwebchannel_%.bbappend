require fixup-pkgconfig.inc
