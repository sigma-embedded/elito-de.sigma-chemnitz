require fixup-pkgconfig.inc

PACKAGECONFIG_append = " gstreamer"
