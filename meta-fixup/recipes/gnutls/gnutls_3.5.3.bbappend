FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "\
  file://001_gnutls_check_SYS_getrandom.patch \
"
