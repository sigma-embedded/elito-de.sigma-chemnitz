INITSCRIPT_PACKAGES = "${PN}-sysv"
