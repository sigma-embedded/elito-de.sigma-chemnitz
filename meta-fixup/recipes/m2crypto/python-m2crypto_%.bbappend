FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "\
  file://d6b509030dfa12ee299f0de623fb78f2223e6579.patch \
"
