FILESEXTRAPATHS_prepend := "${THISDIR}:"

SRC_URI += "file://min.patch"
