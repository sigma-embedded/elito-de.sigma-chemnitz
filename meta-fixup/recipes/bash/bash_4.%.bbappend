ALTERNATIVE_PRIORITY = "30"
