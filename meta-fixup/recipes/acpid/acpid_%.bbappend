FILESEXTRAPATHS_prepend := "${THISDIR}:"
SRC_URI += "file://no-werror.patch"
