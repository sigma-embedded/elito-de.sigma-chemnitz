FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://kernel-3.10.patch"
