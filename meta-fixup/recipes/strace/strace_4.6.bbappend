FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://syscall-hole.patch"
