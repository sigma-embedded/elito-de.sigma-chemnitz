PROFILETOOLS_append_arm = " arm-memspeed"
