FILESEXTRAPATHS_prepend := "${THISDIR}:"
SRC_URI += "file://chmod-modes.patch"
