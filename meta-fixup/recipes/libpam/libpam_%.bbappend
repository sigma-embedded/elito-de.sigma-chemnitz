do_configure_prepend() {
	echo 'LIBTOOL = libtool' >> ${S}/doc/specs/Makefile.am
}
