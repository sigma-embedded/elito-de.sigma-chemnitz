RPROVIDES_${PN} += "perl-module-warnings-register"
