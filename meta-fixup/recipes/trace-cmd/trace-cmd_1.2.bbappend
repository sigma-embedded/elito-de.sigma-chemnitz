EXTRA_OEMAKE += "BUILD_PYTHON= PYTHON_PLUGINS= PYTHON_GUI= PYTHON_SO_INSTALL= PYTHON_PY_INSTALL="
