RDEPENDS_${PN} += "kexec kdump"
ALLOW_EMPTY_${PN} = "1"
