do_configure_append() {
	rm -f include/linux/types.h
}
