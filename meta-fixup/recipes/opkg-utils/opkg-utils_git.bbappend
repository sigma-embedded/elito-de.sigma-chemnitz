FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-opkg-do-not-invoke-find-when-existence-of-file-can-b.patch"
