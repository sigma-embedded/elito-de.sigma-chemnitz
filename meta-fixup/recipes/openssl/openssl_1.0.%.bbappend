FILESEXTRAPATHS_prepend := "${THISDIR}/openssl-1.0:"

SRC_URI += "file://ccache.patch"
