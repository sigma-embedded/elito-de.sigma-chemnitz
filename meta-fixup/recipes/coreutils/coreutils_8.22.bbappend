FILESEXTRAPATHS_prepend := "${THISDIR}:"

SRC_URI += "file://chmod-w.patch"
