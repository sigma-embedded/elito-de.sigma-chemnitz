DISTRO_FEATURES += "sysvinit"
