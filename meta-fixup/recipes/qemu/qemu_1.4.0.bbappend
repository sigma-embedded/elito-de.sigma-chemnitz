do_configure_prepend() {
    rm include/libfdt_env.h
}
