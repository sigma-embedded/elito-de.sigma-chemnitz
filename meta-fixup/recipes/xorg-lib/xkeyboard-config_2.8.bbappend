EXTRA_AUTORECONF += '--exclude=autopoint'
