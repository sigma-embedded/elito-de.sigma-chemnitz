do_build[recrdeptask] += "do_pkg_write_metainfo do_distribute_sources"
